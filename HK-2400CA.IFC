Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-2400CA.IFC
Time: 2022-01-05T02:17:12
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 24出風口(理想狀況)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 24出風口柵門_加螺紋
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: E型夾片4mm (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: sensor橡皮
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 圓角10
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 圓角9
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 外殼螺絲(鐵板用) (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 底座(琺瑯)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 感應器
In: Default Storey
PredefinedType: ELEMENT; Material: 0
